File: master-circuit-v0.2/group-of-8-servo-connectors.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: Convert to kicad 10.
Parts:
- U21, U22, U23: value ~ -> (none)
